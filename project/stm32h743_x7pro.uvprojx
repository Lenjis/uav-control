# Keil uVision project stm32h743_x7pro.uvprojx, settings and files
target x7pro (ARM-ADS)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: stm32h743_x7pro
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H7xx
  c misc: -g -W
  c include: .\;.\startup;.\hardwares;.\devices;.\maths;.\navigation_ESKF;.\GPS_message;.\TCP;.\data_struct;.\LIB;.\TELE;.\sim_control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8200000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group hardwares
    ./hardwares/: sbus.c mpwmout.c
  group startup
    ./startup/: init.c main.cpp
    ./hardwares/: usart.h
  group LIB
    ./LIB/: stm32h743_x7pro_drives.lib stm32h743_x7pro_ESKF.lib
  group TELE
    ./TELE/: tele.cpp teleH.h state_define.cpp state_define.h
  group sim_control
    ./sim_control/: sim.cpp Sim.h
